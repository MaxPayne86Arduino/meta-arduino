# Placeholder, empty recipe for now

LICENSE = "CLOSED"
