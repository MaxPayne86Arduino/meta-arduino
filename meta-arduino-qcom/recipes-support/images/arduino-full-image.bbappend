require ${THISDIR}/arduino-multimedia-image-qcom.inc
