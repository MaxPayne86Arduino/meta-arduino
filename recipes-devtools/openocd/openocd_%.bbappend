EXTRA_OECONF:append:portenta-x8 = " --enable-imx_gpio"
PACKAGECONFIG:append:portenta-x8 = " sysfsgpio"

EXTRA_OECONF:append:portenta-x9 = " --enable-imx_gpio"
PACKAGECONFIG:append:portenta-x9 = " sysfsgpio"
