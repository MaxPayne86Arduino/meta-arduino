PACKAGECONFIG:append = " aklite-offline"

